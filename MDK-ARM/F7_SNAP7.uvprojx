# Keil uVision project F7_SNAP7.uvprojx, settings and files
target F7_SNAP7 (ARM-ADS)
  device: STM32F767ZITx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: F7_SNAP7
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F767xx
  c include: ../Inc;       ../Middlewares/Third_Party/LwIP/src/include;       ../Middlewares/Third_Party/LwIP/system;       ../Drivers/STM32F7xx_HAL_Driver/Inc;       ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;       ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;       ../Middlewares/Third_Party/LwIP/src/include/netif/ppp;       ../Drivers/CMSIS/Device/ST/STM32F7xx/Include;       ../Middlewares/Third_Party/FreeRTOS/Source/include;       ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;       ../Middlewares/Third_Party/LwIP/src/include/lwip;       ../Middlewares/Third_Party/LwIP/src/include/lwip/apps;       ../Middlewares/Third_Party/LwIP/src/include/lwip/priv;       ../Middlewares/Third_Party/LwIP/src/include/lwip/prot;       ../Middlewares/Third_Party/LwIP/src/include/netif;       ../Middlewares/Third_Party/LwIP/src/include/posix;       ../Middlewares/Third_Party/LwIP/src/include/posix/sys;       ../Middlewares/Third_Party/LwIP/system/arch;       ../Drivers/CMSIS/Include;       ..\Modbus\Modbus_Ascii;       ..\Modbus\Modbus_Rtu;       ..\Modbus\Modbus_Tcp;       ..\Modbus
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32f767xx.s
  group Modbus
    ../Modbus/Modbus_Ascii/: modbus_ascii.c modbus_ascii_func.c
    ../Modbus/Modbus_Rtu/: modbus_rtu.c modbus_rtu_func.c
    ../Modbus/Modbus_Tcp/: modbus_tcp.c modbus_tcp_func.c
    ../Modbus/: modbus_register.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: tasks.c queue.c event_groups.c croutine.c list.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_uart.c stm32f7xx_hal_tim.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_gpio.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_dma.c stm32f7xx_hal_pwr.c stm32f7xx_hal_eth.c stm32f7xx_hal.c stm32f7xx_hal_i2c_ex.c
  group Application/User
    ../Src/: usart.c gpio.c lwip.c stm32f7xx_hal_msp.c ethernetif.c adc.c main.c freertos.c stm32f7xx_it.c stdio.c dma.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: pppcrypt.c vj.c auth.c demand.c upap.c pppapi.c chap-new.c fsm.c chap-md5.c magic.c mppe.c ipcp.c pppol2tp.c lcp.c ipv6cp.c ppp.c utils.c multilink.c eui64.c eap.c ccp.c ecp.c chap_ms.c pppoe.c pppos.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: ip4_addr.c autoip.c etharp.c igmp.c icmp.c ip4.c ip4_frag.c dhcp.c
    ../Middlewares/Third_Party/LwIP/src/api/: tcpip.c netdb.c api_msg.c api_lib.c netifapi.c err.c sockets.c netbuf.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: nd6.c mld6.c inet6.c dhcp6.c ip6_frag.c ethip6.c icmp6.c ip6.c ip6_addr.c
    ../Middlewares/Third_Party/LwIP/src/core/: netif.c stats.c tcp_in.c inet_chksum.c timeouts.c tcp.c tcp_out.c sys.c init.c def.c memp.c ip.c dns.c pbuf.c udp.c raw.c mem.c
    ../Middlewares/Third_Party/LwIP/src/netif/: ethernet.c lowpan6.c slipif.c
    ../Middlewares/Third_Party/LwIP/src/apps/mqtt/: mqtt.c
software components: CMSIS:CORE 4.3.0
